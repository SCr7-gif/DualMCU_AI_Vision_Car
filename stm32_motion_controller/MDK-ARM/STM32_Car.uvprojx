# Keil uVision project STM32_Car.uvprojx, settings and files
target STM32_Car (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_Car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../User;../User/App;../User/BSP;../User/Devices;../User/Protocol;../User/Utils;../TestOnly/stm32_test_mode;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/App
    ../User/App/: app_main.c safety_manager.c car_control.c gimbal_control.c behavior_executor.c
  group Application/User/BSP
    ../User/BSP/: bsp_motor.c bsp_dht11.c bsp_ultrasonic.c bsp_servo.c bsp_ws2812.c bsp_gps.c
  group Application/User/Utils
    ../User/Utils/: easing.c
  group Application/User/Protocol
    ../User/Protocol/: car_protocol.c command_handler.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group TestOnly/stm32_test_mode
    ../TestOnly/stm32_test_mode/: test_app.c test_protocol.c test_motor.c test_servo.c test_ultrasonic.c test_dht11.c test_gps.c test_ws2812.c test_app.h test_dht11.h test_gps.h test_motor.h test_protocol.h test_servo.h test_ultrasonic.h test_ws2812.h
software components: CMSIS:CORE 4.3.0
